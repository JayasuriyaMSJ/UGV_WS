Commit message: work

File: ros2_ws/src/webots_platform/config/Robot.urdf (robot description, URDF)
Before this commit: robot /home/suriya/ros2_ws/src/webots_platform/config/Robot.urdf, 14 links, 13 joints
Links:
- link chassis: geometry visual box size=0.6 0.5 0.2
